# Keil uVision project systick.uvprojx, settings and files
target KL03-systick (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x1FFFFE00,0x0800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: systick_Flash +hex
  AfterMake: fromelf --m32combined --output=outfile.s19  systick_Flash.axf
  c flags: Optim=4
  c define: KEIL FREEDOM CMSIS
  c include: ..\..\..\src\projects\systick;..\..\..\src\common;..\..\..\src\cpu;..\..\..\src\cpu\headers;..\..\..\src\drivers\lptmr;..\..\..\src\drivers\mcg;..\..\..\src\drivers\pmc;..\..\..\src\drivers\rcm;..\..\..\src\drivers\smc;..\..\..\src\drivers\uart;..\..\..\src\drivers\cmp;..\..\..\src\platforms;..\..;..\startup_s;..\..\..\src\drivers\gpio;..\..\..\src\drivers\lptmr;..\..\..\src\drivers\I2C;..\..\..\src\drivers\smc;..\..\..\src\drivers\adc;..\..\..\src\drivers\cmp;..\..\..\src\projects
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffe00 size 0x200
  memory RVCT10: RAM 0x20000000 size 0x600
  group project
    ../startup_s/: startup_MKL03Z4.s
    ../../../src/projects/systick/: main.c
  group common
    ../../../src/common/: uif.c alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ../../../src/cpu/: nmi_isr_handler.c sysinit.c arm_cm0.c start.c
  group drivers
    ../../../src/drivers/uart/: uart.c Retarget.c Serial.c
    ../../../src/drivers/rcm/: rcm.c rcm.h
    ../../../src/drivers/mcg/: mcg_lite.c
    ../../../src/drivers/lptmr/: lptmr.c
    ../../../src/drivers/I2C/: hal_dev_mma8451.c hal_i2c.c
    ../../../src/drivers/smc/: smc.c
    ../../../src/drivers/adc/: adc.c
    ../../../src/drivers/cmp/: cmp.c
  group platforms
    ../../../src/platforms/: freedom.h
